## boards/st/kore_microvisor/board.yml
```yaml
board:
  name: kore_microvisor
  vendor: st
  socs:
    - name: stm32u585xx
      variants:
        - name: ns
```
